FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-triple-redudancy-to-TX2i-filesystem.patch"

