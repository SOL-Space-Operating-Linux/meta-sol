# Set hostname (Default value is $MACHINE$)
hostname_pn-base-files = "tegra-sol"