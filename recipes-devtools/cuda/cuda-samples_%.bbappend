CUDA_SAMPLES += " \
    0_Simple/UnifiedMemoryStreams \
    1_Utilities/deviceQuery \
    6_Advanced/mergeSort \
    1_Utilities/bandwidthTest \
"