CUDA_SAMPLES_append = " 1_Utilities/bandwidthTest 1_Utilities/UnifiedMemoryPerf"

LINKFLAGS_append = " -lm"
